options:
  parameters:
    generate_options: qt_gui
    id: kraken_fft_display
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: cpi_size
  id: variable
  parameters:
    value: 2**20
  states: {}
- name: freq
  id: variable_qtgui_entry
  parameters:
    gui_hint: (0,0)
    label: Center Frequency [MHz]
    type: real
    value: '1420.40575'
  states: {}
- name: gain
  id: variable_qtgui_entry
  parameters:
    gui_hint: (0,1)
    label: Gain [0 - 49.6]
    type: real
    value: '40.2'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2400000'
  states: {}
- name: vec_len
  id: variable
  parameters:
    value: 2**14
  states: {}
- name: blocks_multiply_conjugate_cc_0
  id: blocks_multiply_conjugate_cc
  parameters:
    vlen: vec_len
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: vec_len
    type: complex
  states: {}
- name: blocks_stream_to_vector_0_0
  id: blocks_stream_to_vector
  parameters:
    num_items: vec_len
    type: complex
  states: {}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: vec_len
    type: complex
  states: {}
- name: krakensdr_krakensdr_source_0
  id: krakensdr_krakensdr_source
  parameters:
    ctrlPort: '5001'
    debug: 'False'
    freq: freq
    gain: '[gain, gain]'
    ipAddr: 127.0.0.1
    numChannels: '2'
    port: '5000'
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: freq
    fftsize: '1024'
    gui_hint: (1,0)
    name: ch_0
    plotconst: 'False'
    plottime: 'False'
    showrf: 'True'
    type: complex
  states: {}

connections:
- [blocks_multiply_conjugate_cc_0, '0', blocks_vector_to_stream_0, '0']
- [blocks_stream_to_vector_0, '0', blocks_multiply_conjugate_cc_0, '0']
- [blocks_stream_to_vector_0_0, '0', blocks_multiply_conjugate_cc_0, '1']
- [blocks_vector_to_stream_0, '0', qtgui_sink_x_0, '0']
- [krakensdr_krakensdr_source_0, '0', blocks_stream_to_vector_0, '0']
- [krakensdr_krakensdr_source_0, '1', blocks_stream_to_vector_0_0, '0']

metadata:
  file_format: 1
