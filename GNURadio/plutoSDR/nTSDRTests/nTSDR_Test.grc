options:
  parameters:
    author: ubuntu
    generate_options: qt_gui
    id: nTSDR_Test
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: freq
  id: variable
  parameters:
    value: '100000000'
  states: {}
- name: pluto1
  id: variable
  parameters:
    value: '"ip:192.168.2.1"'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2000000'
  states: {}
- name: iio_fmcomms2_source_0
  id: iio_fmcomms2_source
  parameters:
    bandwidth: '20000000'
    bbdc: 'True'
    buffer_size: '32768'
    filter_source: '''Auto'''
    frequency: freq
    gain1: '''slow_attack'''
    gain2: '''slow_attack'''
    quadrature: 'True'
    rf_port_select: '''A_BALANCED'''
    rfdc: 'True'
    rx1_en: 'True'
    rx2_en: 'True'
    samplerate: samp_rate
    type: fc32
    uri: pluto1
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '5000'
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: '2000'
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_1
  id: low_pass_filter
  parameters:
    cutoff_freq: '5000'
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: '2000'
    win: window.WIN_HAMMING
  states: {}
- name: nTSDR_phaseLock_0
  id: nTSDR_phaseLock
  parameters:
    num_channels: '2'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    label1: Unchanged
    label2: Phase Adjusted
    name: '"Frequency"'
    nconnections: '2'
    type: complex
    ymax: '-40'
    ymin: '-150'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    alpha3: '0'
    alpha4: '0'
    label1: Unchanged
    label2: Phase Adjusted
    label3: ''
    label4: ''
    name: Time
    nconnections: '2'
    size: '1024'
    srate: samp_rate
    style3: '0'
    style4: '0'
    type: complex
    width3: '0'
    width4: '0'
    ymax: '0.005'
    ymin: '-0.005'
  states: {}

connections:
- [iio_fmcomms2_source_0, '0', low_pass_filter_0, '0']
- [iio_fmcomms2_source_0, '1', low_pass_filter_1, '0']
- [low_pass_filter_0, '0', nTSDR_phaseLock_0, '0']
- [low_pass_filter_0, '0', qtgui_freq_sink_x_0, '0']
- [low_pass_filter_1, '0', nTSDR_phaseLock_0, '1']
- [low_pass_filter_1, '0', qtgui_time_sink_x_0, '0']
- [nTSDR_phaseLock_0, '0', qtgui_freq_sink_x_0, '1']
- [nTSDR_phaseLock_0, '1', qtgui_time_sink_x_0, '1']

metadata:
  file_format: 1
