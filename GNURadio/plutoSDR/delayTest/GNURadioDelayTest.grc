options:
  parameters:
    author: ubuntu
    generate_options: qt_gui
    id: GNURadioDelayTest
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: Rx1_Delay
  id: variable
  parameters:
    value: '50'
  states: {state: disabled}
- name: Rx1_Delay
  id: variable_qtgui_range
  parameters:
    label: Rx1 Delay
    rangeType: int
    start: '0'
    step: '1'
    stop: '200'
    value: '0'
  states: {state: disabled}
- name: Rx1_Delay_Sec
  id: variable
  parameters:
    value: Rx1_Delay * samp_rate
  states: {state: disabled}
- name: Rx2_Delay
  id: variable
  parameters:
    value: '0'
  states: {state: disabled}
- name: Rx2_Delay
  id: variable_qtgui_range
  parameters:
    label: Rx2 Delay
    rangeType: int
    start: '0'
    step: '1'
    stop: '200'
    value: '0'
  states: {state: disabled}
- name: freq
  id: variable
  parameters:
    value: '100000000'
  states: {}
- name: freq_gui
  id: variable_qtgui_range
  parameters:
    label: Frequency
    rangeType: int
    start: '70000000'
    step: '5000000'
    stop: '90000000'
    value: '70000000'
  states: {}
- name: pluto1
  id: variable
  parameters:
    value: '"ip:192.168.2.1"'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2000000'
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: Rx1_Delay
    type: complex
  states: {state: disabled}
- name: blocks_delay_0_0
  id: blocks_delay
  parameters:
    delay: Rx2_Delay
    type: complex
  states: {state: disabled}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: iio_fmcomms2_source_0
  id: iio_fmcomms2_source
  parameters:
    bandwidth: '20000000'
    bbdc: 'True'
    buffer_size: '32768'
    filter_source: '''Auto'''
    frequency: freq
    gain1: '''slow_attack'''
    gain2: '''slow_attack'''
    quadrature: 'True'
    rf_port_select: '''B_BALANCED'''
    rfdc: 'True'
    rx1_en: 'True'
    rx2_en: 'True'
    samplerate: samp_rate
    type: fc32
    uri: pluto1
  states: {state: disabled}
- name: iio_fmcomms2_source_0_0
  id: iio_fmcomms2_source
  parameters:
    bandwidth: '20000000'
    bbdc: 'True'
    buffer_size: '32768'
    filter_source: '''Auto'''
    frequency: freq_gui
    gain1: '''slow_attack'''
    quadrature: 'True'
    rf_port_select: '''B_BALANCED'''
    rfdc: 'True'
    rx1_en: 'True'
    rx2_en: 'False'
    samplerate: samp_rate
    type: fc32
    uri: pluto1
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '5000'
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: '2000'
    win: window.WIN_HAMMING
  states: {state: disabled}
- name: low_pass_filter_0_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '5000'
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: '2000'
    win: window.WIN_HAMMING
  states: {state: disabled}
- name: low_pass_filter_0_3
  id: low_pass_filter
  parameters:
    cutoff_freq: '5000'
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: '2000'
    win: window.WIN_HAMMING
  states: {}
- name: note_0_0
  id: note
  parameters:
    note: Single Pluto - Dual Rx
  states: {state: disabled}
- name: note_1
  id: note
  parameters:
    note: 'README: Single Pluto - Single Rx - This is a test to control frequency for GUI influence'
  states: {}
- name: qtgui_freq_sink_x_0_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    grid: 'True'
    label1: Rx1
    label2: Rx2
    nconnections: '2'
    type: complex
    ymax: '-50'
    ymin: '-180'
  states: {state: disabled}
- name: qtgui_freq_sink_x_0_1
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    label1: Single Pluto Rx1
    type: complex
    ymax: '-50'
    ymin: '-180'
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    label1: Rx1
    label2: Rx2
    label3: ''
    label4: ''
    nconnections: '2'
    size: '1024'
    srate: samp_rate
    style3: '0'
    style4: '0'
    type: complex
    ymax: '0.005'
    ymin: '-0.005'
  states: {state: disabled}
- name: qtgui_time_sink_x_0_1
  id: qtgui_time_sink_x
  parameters:
    label1: Single Pluto Rx1
    label2: ''
    size: '1024'
    srate: samp_rate
    style2: '0'
    type: complex
    ymax: '0.005'
    ymin: '-0.005'
  states: {}

connections:
- [blocks_delay_0, '0', low_pass_filter_0, '0']
- [blocks_delay_0_0, '0', low_pass_filter_0_0_0, '0']
- [blocks_throttle2_0, '0', qtgui_freq_sink_x_0_1, '0']
- [blocks_throttle2_0, '0', qtgui_time_sink_x_0_1, '0']
- [iio_fmcomms2_source_0, '0', blocks_delay_0, '0']
- [iio_fmcomms2_source_0, '1', blocks_delay_0_0, '0']
- [iio_fmcomms2_source_0_0, '0', low_pass_filter_0_3, '0']
- [low_pass_filter_0, '0', qtgui_freq_sink_x_0_0_0, '0']
- [low_pass_filter_0, '0', qtgui_time_sink_x_0_0, '0']
- [low_pass_filter_0_0_0, '0', qtgui_freq_sink_x_0_0_0, '1']
- [low_pass_filter_0_0_0, '0', qtgui_time_sink_x_0_0, '1']
- [low_pass_filter_0_3, '0', blocks_throttle2_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.7.0
