options:
  parameters:
    generate_options: qt_gui
    id: FMCommsTest
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: P2_path
  id: variable
  parameters:
    value: '"/home/sdr/code/sdr-beamforming/GNURadio/plutoSDR/dualPlutoFileSink/fileOutputP2.iq"'
  states: {}
- name: P3_path
  id: variable
  parameters:
    value: '"/home/sdr/code/sdr-beamforming/GNURadio/plutoSDR/dualPlutoFileSink/fileOutputP3.iq"'
  states: {}
- name: P4_path
  id: variable
  parameters:
    value: '"/home/sdr/code/sdr-beamforming/GNURadio/plutoSDR/dualPlutoFileSink/fileOutputP4.iq"'
  states: {}
- name: P5_path
  id: variable
  parameters:
    value: '"/home/sdr/code/sdr-beamforming/GNURadio/plutoSDR/dualPlutoFileSink/fileOutputP5.iq"'
  states: {}
- name: baseband
  id: variable
  parameters:
    value: '500'
  states: {}
- name: freq
  id: variable
  parameters:
    value: '915000000'
  states: {}
- name: pluto2
  id: variable
  parameters:
    value: '"ip:192.168.2.1"'
  states: {}
- name: pluto3
  id: variable
  parameters:
    value: '"ip:192.168.3.1"'
  states: {}
- name: pluto4
  id: variable
  parameters:
    value: '"ip:192.168.4.1"'
  states: {}
- name: pluto5
  id: variable
  parameters:
    value: '"ip:192.168.5.1"'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2000000'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: baseband
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: P2_path
    type: complex
  states: {}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: P4_path
    type: complex
  states: {state: disabled}
- name: blocks_file_sink_0_1
  id: blocks_file_sink
  parameters:
    file: P5_path
    type: complex
  states: {state: disabled}
- name: blocks_file_sink_0_2
  id: blocks_file_sink
  parameters:
    file: P4_path
    type: complex
  states: {}
- name: blocks_file_sink_0_2_0
  id: blocks_file_sink
  parameters:
    file: P5_path
    type: complex
  states: {}
- name: blocks_file_sink_0_3
  id: blocks_file_sink
  parameters:
    file: P3_path
    type: complex
  states: {}
- name: iio_fmcomms2_sink_0
  id: iio_fmcomms2_sink
  parameters:
    attenuation1: '12'
    bandwidth: '20000000'
    buffer_size: '4096'
    cyclic: 'False'
    filter_source: '''Auto'''
    frequency: freq
    rf_port_select: '''A'''
    samplerate: samp_rate
    tx1_en: 'True'
    tx2_en: 'False'
    type: fc32
    uri: pluto4
  states: {}
- name: iio_fmcomms2_source_0_0
  id: iio_fmcomms2_source
  parameters:
    bandwidth: '20000000'
    bbdc: 'True'
    buffer_size: '32768'
    filter_source: '''Auto'''
    frequency: freq
    gain1: '''manual'''
    gain2: '''manual'''
    manual_gain1: '40'
    manual_gain2: '40'
    quadrature: 'True'
    rf_port_select: '''A_BALANCED'''
    rfdc: 'True'
    rx1_en: 'True'
    rx2_en: 'True'
    samplerate: samp_rate
    type: fc32
    uri: pluto2
  states: {}
- name: iio_fmcomms2_source_0_0_0
  id: iio_fmcomms2_source
  parameters:
    bandwidth: '20000000'
    bbdc: 'True'
    buffer_size: '32768'
    filter_source: '''Auto'''
    frequency: freq
    gain1: '''manual'''
    manual_gain1: '32'
    quadrature: 'True'
    rf_port_select: '''A_BALANCED'''
    rfdc: 'True'
    rx1_en: 'True'
    rx2_en: 'False'
    samplerate: samp_rate
    type: fc32
    uri: pluto4
  states: {state: disabled}
- name: iio_fmcomms2_source_0_0_0_0
  id: iio_fmcomms2_source
  parameters:
    bandwidth: '20000000'
    bbdc: 'True'
    buffer_size: '32768'
    filter_source: '''Auto'''
    frequency: freq
    gain1: '''manual'''
    manual_gain1: '32'
    quadrature: 'True'
    rf_port_select: '''A_BALANCED'''
    rfdc: 'True'
    rx1_en: 'True'
    rx2_en: 'False'
    samplerate: samp_rate
    type: fc32
    uri: pluto5
  states: {state: disabled}
- name: iio_fmcomms2_source_0_0_1
  id: iio_fmcomms2_source
  parameters:
    bandwidth: '20000000'
    bbdc: 'True'
    buffer_size: '32768'
    filter_source: '''Auto'''
    frequency: freq
    gain1: '''manual'''
    gain2: '''manual'''
    manual_gain1: '40'
    manual_gain2: '40'
    quadrature: 'True'
    rf_port_select: '''A_BALANCED'''
    rfdc: 'True'
    rx1_en: 'True'
    rx2_en: 'True'
    samplerate: samp_rate
    type: fc32
    uri: pluto4
  states: {}
- name: iio_pluto_sink_0
  id: iio_pluto_sink
  parameters:
    attenuation1: '20'
    bandwidth: '20000000'
    buffer_size: '32768'
    cyclic: 'False'
    filter_source: '''Auto'''
    frequency: freq
    samplerate: samp_rate
    type: fc32
    uri: pluto2
  states: {state: disabled}
- name: low_pass_filter_0_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '5000'
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: '2000'
    win: window.WIN_HAMMING
  states: {state: disabled}
- name: low_pass_filter_0_0_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '5000'
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: '2000'
    win: window.WIN_HAMMING
  states: {state: disabled}
- name: low_pass_filter_0_0_0_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '5000'
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: '2000'
    win: window.WIN_HAMMING
  states: {state: disabled}
- name: low_pass_filter_0_0_0_1
  id: low_pass_filter
  parameters:
    cutoff_freq: '5000'
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: '2000'
    win: window.WIN_HAMMING
  states: {state: disabled}
- name: low_pass_filter_0_0_0_1_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '5000'
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: '2000'
    win: window.WIN_HAMMING
  states: {state: disabled}
- name: low_pass_filter_0_0_0_2
  id: low_pass_filter
  parameters:
    cutoff_freq: '5000'
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: '2000'
    win: window.WIN_HAMMING
  states: {state: disabled}
- name: low_pass_filter_0_2
  id: low_pass_filter
  parameters:
    cutoff_freq: '5000'
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: '2000'
    win: window.WIN_HAMMING
  states: {state: disabled}
- name: note_0_0
  id: note
  parameters:
    note: This is for Tx - Single Pluto
  states: {}
- name: note_0_1
  id: note
  parameters:
    note: This is for FMComms Testing - Four Plutos
  states: {}

connections:
- [analog_sig_source_x_0, '0', iio_fmcomms2_sink_0, '0']
- [analog_sig_source_x_0, '0', iio_pluto_sink_0, '0']
- [analog_sig_source_x_0, '0', low_pass_filter_0_2, '0']
- [iio_fmcomms2_source_0_0, '0', blocks_file_sink_0, '0']
- [iio_fmcomms2_source_0_0, '0', low_pass_filter_0_0_0, '0']
- [iio_fmcomms2_source_0_0, '1', blocks_file_sink_0_3, '0']
- [iio_fmcomms2_source_0_0, '1', low_pass_filter_0_0_0_2, '0']
- [iio_fmcomms2_source_0_0_0, '0', low_pass_filter_0_0_0_0, '0']
- [iio_fmcomms2_source_0_0_0_0, '0', low_pass_filter_0_0_0_0_0, '0']
- [iio_fmcomms2_source_0_0_1, '0', blocks_file_sink_0_2, '0']
- [iio_fmcomms2_source_0_0_1, '0', low_pass_filter_0_0_0_1, '0']
- [iio_fmcomms2_source_0_0_1, '1', blocks_file_sink_0_2_0, '0']
- [iio_fmcomms2_source_0_0_1, '1', low_pass_filter_0_0_0_1_0, '0']
- [low_pass_filter_0_0_0, '0', blocks_file_sink_0, '0']
- [low_pass_filter_0_0_0_0, '0', blocks_file_sink_0_0, '0']
- [low_pass_filter_0_0_0_0_0, '0', blocks_file_sink_0_1, '0']
- [low_pass_filter_0_0_0_1, '0', blocks_file_sink_0_2, '0']
- [low_pass_filter_0_0_0_1_0, '0', blocks_file_sink_0_2_0, '0']
- [low_pass_filter_0_0_0_2, '0', blocks_file_sink_0_3, '0']
- [low_pass_filter_0_2, '0', iio_pluto_sink_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.7.0
