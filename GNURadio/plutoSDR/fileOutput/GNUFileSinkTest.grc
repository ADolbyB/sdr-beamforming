options:
  parameters:
    author: ubuntu
    generate_options: qt_gui
    id: fileSinkTest
    output_language: python
    title: File Sink Test
  states: {}

blocks:
- name: freq
  id: variable
  parameters:
    value: '100000000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2000000'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/ubuntu/PlutoSDR/sdr-beamforming/GNURadio/fileOutput
    type: complex
  states: {}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    bandwidth: '20000000'
    bbdc: 'True'
    buffer_size: '32768'
    filter_source: '''Auto'''
    frequency: freq
    gain1: '''manual'''
    manual_gain1: '64'
    quadrature: 'True'
    rfdc: 'True'
    samplerate: samp_rate
    type: fc32
    uri: ip:192.168.2.1
  states: {}
- name: low_pass_filter_0_1
  id: low_pass_filter
  parameters:
    cutoff_freq: '5000'
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: '2000'
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}

connections:
- [iio_pluto_source_0, '0', low_pass_filter_0_1, '0']
- [low_pass_filter_0_1, '0', blocks_file_sink_0, '0']
- [low_pass_filter_0_1, '0', qtgui_freq_sink_x_0, '0']
- [low_pass_filter_0_1, '0', qtgui_time_sink_x_0, '0']

metadata:
  file_format: 1
