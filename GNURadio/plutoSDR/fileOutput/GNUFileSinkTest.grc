options:
  parameters:
    author: ubuntu
    generate_options: qt_gui
    id: fileSinkTest
    output_language: python
    title: File Sink Test
  states: {}

blocks:
- name: Rx1_path
  id: variable
  parameters:
    value: '"/home/ubuntu/PlutoSDR/sdr-beamforming/GNURadio/plutoSDR/fileOutput/fileOutputRx1"'
  states: {}
- name: Rx2_path
  id: variable
  parameters:
    value: '"/home/ubuntu/PlutoSDR/sdr-beamforming/GNURadio/plutoSDR/fileOutput/fileOutputRx2"'
  states: {}
- name: freq
  id: variable
  parameters:
    value: '100000000'
  states: {}
- name: pluto1
  id: variable
  parameters:
    value: '"ip:192.168.2.1"'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2000000'
  states: {}
- name: single_path
  id: variable
  parameters:
    value: '"/home/ubuntu/PlutoSDR/sdr-beamforming/GNURadio/plutoSDR/fileOutput/fileOutput"'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: single_path
    type: complex
  states: {state: disabled}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: Rx1_path
    type: complex
  states: {}
- name: blocks_file_sink_0_0_0
  id: blocks_file_sink
  parameters:
    file: Rx2_path
    type: complex
  states: {}
- name: iio_fmcomms2_source_0
  id: iio_fmcomms2_source
  parameters:
    bandwidth: '20000000'
    bbdc: 'True'
    buffer_size: '32768'
    filter_source: '''Auto'''
    frequency: freq
    gain1: '''slow_attack'''
    gain2: '''slow_attack'''
    quadrature: 'True'
    rf_port_select: '''B_BALANCED'''
    rfdc: 'True'
    rx1_en: 'True'
    rx2_en: 'True'
    samplerate: samp_rate
    type: fc32
    uri: pluto1
  states: {}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    bandwidth: '20000000'
    bbdc: 'True'
    buffer_size: '32768'
    filter_source: '''Auto'''
    frequency: freq
    gain1: '''manual'''
    manual_gain1: '64'
    quadrature: 'True'
    rfdc: 'True'
    samplerate: samp_rate
    type: fc32
    uri: ip:192.168.2.1
  states: {state: disabled}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '5000'
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: '2000'
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '5000'
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: '2000'
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '5000'
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: '2000'
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_1
  id: low_pass_filter
  parameters:
    cutoff_freq: '5000'
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: '2000'
    win: window.WIN_HAMMING
  states: {state: disabled}
- name: low_pass_filter_0_1_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '5000'
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: '2000'
    win: window.WIN_HAMMING
  states: {}
- name: note_0
  id: note
  parameters:
    note: Single Pluto - Rx1
  states: {state: disabled}
- name: note_0_0
  id: note
  parameters:
    note: Single Pluto - Dual Rx
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {state: disabled}
- name: qtgui_freq_sink_x_0_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    grid: 'True'
    label1: Rx1
    label2: Rx2
    nconnections: '2'
    type: complex
    ymax: '-50'
    ymin: '-180'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    label1: Rx1
    label2: Rx2
    label3: ''
    label4: ''
    nconnections: '2'
    size: '1024'
    srate: samp_rate
    style3: '0'
    style4: '0'
    type: complex
    ymax: '0.005'
    ymin: '-0.005'
  states: {}

connections:
- [iio_fmcomms2_source_0, '0', low_pass_filter_0, '0']
- [iio_fmcomms2_source_0, '0', low_pass_filter_0_0, '0']
- [iio_fmcomms2_source_0, '1', low_pass_filter_0_0_0, '0']
- [iio_fmcomms2_source_0, '1', low_pass_filter_0_1_0, '0']
- [iio_pluto_source_0, '0', low_pass_filter_0_1, '0']
- [low_pass_filter_0, '0', blocks_file_sink_0_0, '0']
- [low_pass_filter_0, '0', qtgui_time_sink_x_0_0, '0']
- [low_pass_filter_0_0, '0', qtgui_freq_sink_x_0_0_0, '0']
- [low_pass_filter_0_0_0, '0', blocks_file_sink_0_0_0, '0']
- [low_pass_filter_0_0_0, '0', qtgui_freq_sink_x_0_0_0, '1']
- [low_pass_filter_0_1, '0', blocks_file_sink_0, '0']
- [low_pass_filter_0_1, '0', qtgui_freq_sink_x_0, '0']
- [low_pass_filter_0_1, '0', qtgui_time_sink_x_0, '0']
- [low_pass_filter_0_1_0, '0', qtgui_time_sink_x_0_0, '1']

metadata:
  file_format: 1
