options:
  parameters:
    generate_options: qt_gui
    id: FMCommsTest
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: freq
  id: variable
  parameters:
    value: '98800000'
  states: {}
- name: pluto1
  id: variable
  parameters:
    value: '"ip:192.168.2.1"'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '521000'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: freq
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {state: disabled}
- name: iio_fmcomms2_source_0
  id: iio_fmcomms2_source
  parameters:
    bandwidth: '20000000'
    bbdc: 'True'
    buffer_size: '32768'
    filter_source: '''Auto'''
    frequency: freq
    gain1: '''slow_attack'''
    gain2: '''slow_attack'''
    quadrature: 'True'
    rf_port_select: '''B_BALANCED'''
    rfdc: 'True'
    rx1_en: 'True'
    rx2_en: 'True'
    samplerate: samp_rate
    type: fc32
    uri: pluto1
  states: {}
- name: iio_pluto_sink_0
  id: iio_pluto_sink
  parameters:
    attenuation1: '1'
    bandwidth: '20000000'
    buffer_size: '32768'
    cyclic: 'False'
    filter_source: '''Auto'''
    frequency: freq
    samplerate: samp_rate
    type: fc32
    uri: pluto1
  states: {state: disabled}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    bandwidth: '20000000'
    bbdc: 'True'
    buffer_size: '32768'
    filter_source: '''Auto'''
    frequency: freq
    gain1: '''slow_attack'''
    quadrature: 'True'
    rfdc: 'True'
    samplerate: samp_rate
    type: fc32
    uri: pluto1
  states: {state: disabled}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '5000'
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: '2000'
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '5000'
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: '2000'
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '5000'
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: '2000'
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_1
  id: low_pass_filter
  parameters:
    cutoff_freq: '5000'
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: '2000'
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_2
  id: low_pass_filter
  parameters:
    cutoff_freq: '5000'
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: '2000'
    win: window.WIN_HAMMING
  states: {state: disabled}
- name: low_pass_filter_0_3
  id: low_pass_filter
  parameters:
    cutoff_freq: '5000'
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: '2000'
    win: window.WIN_HAMMING
  states: {state: disabled}
- name: note_0
  id: note
  parameters:
    note: This is for FMComms Testing - Single Pluto
  states: {}
- name: note_0_0
  id: note
  parameters:
    note: This is for Tx - Single Pluto
  states: {state: disabled}
- name: note_1
  id: note
  parameters:
    note: This is the default testing for a single Pluto
  states: {state: disabled}
- name: qtgui_freq_sink_x_0_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    grid: 'True'
    label1: Rx1
    label2: Rx2
    nconnections: '2'
    type: complex
    ymax: '-50'
    ymin: '-180'
  states: {}
- name: qtgui_freq_sink_x_0_1
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    label1: Single Pluto Rx1
    type: complex
    ymax: '-50'
    ymin: '-180'
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    label1: Rx1
    label2: Rx2
    label3: ''
    label4: ''
    nconnections: '2'
    size: '1024'
    srate: samp_rate
    style3: '0'
    style4: '0'
    type: complex
    ymax: '0.005'
    ymin: '-0.005'
  states: {}
- name: qtgui_time_sink_x_0_1
  id: qtgui_time_sink_x
  parameters:
    label1: Single Pluto Rx1
    label2: ''
    size: '1024'
    srate: samp_rate
    style2: '0'
    type: complex
    ymax: '0.005'
    ymin: '-0.005'
  states: {state: disabled}

connections:
- [analog_sig_source_x_0, '0', low_pass_filter_0_2, '0']
- [iio_fmcomms2_source_0, '0', low_pass_filter_0, '0']
- [iio_fmcomms2_source_0, '0', low_pass_filter_0_0, '0']
- [iio_fmcomms2_source_0, '1', low_pass_filter_0_0_0, '0']
- [iio_fmcomms2_source_0, '1', low_pass_filter_0_1, '0']
- [iio_pluto_source_0, '0', low_pass_filter_0_3, '0']
- [low_pass_filter_0, '0', qtgui_time_sink_x_0_0, '0']
- [low_pass_filter_0_0, '0', qtgui_freq_sink_x_0_0_0, '0']
- [low_pass_filter_0_0_0, '0', qtgui_freq_sink_x_0_0_0, '1']
- [low_pass_filter_0_1, '0', qtgui_time_sink_x_0_0, '1']
- [low_pass_filter_0_2, '0', iio_pluto_sink_0, '0']
- [low_pass_filter_0_3, '0', qtgui_freq_sink_x_0_1, '0']
- [low_pass_filter_0_3, '0', qtgui_time_sink_x_0_1, '0']

metadata:
  file_format: 1
