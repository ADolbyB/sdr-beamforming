options:
  parameters:
    generate_options: qt_gui
    id: kraken_music_doa
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: cpi_size
  id: variable
  parameters:
    value: 2**20
  states: {}
- name: decimation
  id: variable
  parameters:
    value: '128'
  states: {}
- name: freq
  id: variable
  parameters:
    value: '433.000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2400000'
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: cpi_size//decimation
    type: complex
  states: {}
- name: blocks_stream_to_vector_0_0
  id: blocks_stream_to_vector
  parameters:
    num_items: cpi_size//decimation
    type: complex
  states: {}
- name: blocks_stream_to_vector_0_0_0
  id: blocks_stream_to_vector
  parameters:
    num_items: cpi_size//decimation
    type: complex
  states: {}
- name: blocks_stream_to_vector_0_0_1
  id: blocks_stream_to_vector
  parameters:
    num_items: cpi_size//decimation
    type: complex
  states: {}
- name: blocks_stream_to_vector_0_0_2
  id: blocks_stream_to_vector
  parameters:
    num_items: cpi_size//decimation
    type: complex
  states: {}
- name: blocks_stream_to_vector_1
  id: blocks_stream_to_vector
  parameters:
    num_items: cpi_size
    type: complex
  states: {state: disabled}
- name: blocks_stream_to_vector_1_0
  id: blocks_stream_to_vector
  parameters:
    num_items: cpi_size
    type: complex
  states: {state: disabled}
- name: blocks_stream_to_vector_1_1
  id: blocks_stream_to_vector
  parameters:
    num_items: cpi_size
    type: complex
  states: {state: disabled}
- name: blocks_stream_to_vector_1_2
  id: blocks_stream_to_vector
  parameters:
    num_items: cpi_size
    type: complex
  states: {state: disabled}
- name: blocks_stream_to_vector_1_3
  id: blocks_stream_to_vector
  parameters:
    num_items: cpi_size
    type: complex
  states: {state: disabled}
- name: blocks_vector_to_stream_0_2_0
  id: blocks_vector_to_stream
  parameters:
    num_items: '360'
    type: float
  states: {}
- name: fir_filter_xxx_0
  id: fir_filter_xxx
  parameters:
    decim: decimation
    taps: decimation*5
    type: ccc
  states: {}
- name: fir_filter_xxx_0_0
  id: fir_filter_xxx
  parameters:
    decim: decimation
    taps: decimation*5
    type: ccc
  states: {}
- name: fir_filter_xxx_0_0_0
  id: fir_filter_xxx
  parameters:
    decim: decimation
    taps: decimation*5
    type: ccc
  states: {}
- name: fir_filter_xxx_0_0_1
  id: fir_filter_xxx
  parameters:
    decim: decimation
    taps: decimation*5
    type: ccc
  states: {}
- name: fir_filter_xxx_0_0_2
  id: fir_filter_xxx
  parameters:
    decim: decimation
    taps: decimation*5
    type: ccc
  states: {}
- name: krakensdr_doa_music_0
  id: krakensdr_doa_music
  parameters:
    array_dist: '0.26'
    array_type: '''UCA'''
    freq: freq
    num_elements: '5'
    vec_len: cpi_size//decimation
  states: {}
- name: krakensdr_krakensdr_source_0
  id: krakensdr_krakensdr_source
  parameters:
    ctrlPort: '5001'
    debug: 'False'
    freq: freq
    gain: '[40.2, 40.2, 40.2, 40.2, 40.2]'
    ipAddr: 127.0.0.1
    numChannels: '5'
    port: '5000'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    bw: samp_rate//decimation
    fc: '0'
    fftsize: '2048'
    name: CH_0 Decimated FFT
    type: complex
    update_time: '0.1'
    ymin: '-60'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    name: DOA Graph
    size: '360'
    srate: '1000'
    type: float
  states: {}

connections:
- [blocks_stream_to_vector_0, '0', krakensdr_doa_music_0, '0']
- [blocks_stream_to_vector_0_0, '0', krakensdr_doa_music_0, '1']
- [blocks_stream_to_vector_0_0_0, '0', krakensdr_doa_music_0, '2']
- [blocks_stream_to_vector_0_0_1, '0', krakensdr_doa_music_0, '3']
- [blocks_stream_to_vector_0_0_2, '0', krakensdr_doa_music_0, '4']
- [blocks_stream_to_vector_1, '0', krakensdr_doa_music_0, '0']
- [blocks_stream_to_vector_1_0, '0', krakensdr_doa_music_0, '4']
- [blocks_stream_to_vector_1_1, '0', krakensdr_doa_music_0, '3']
- [blocks_stream_to_vector_1_2, '0', krakensdr_doa_music_0, '1']
- [blocks_stream_to_vector_1_3, '0', krakensdr_doa_music_0, '2']
- [blocks_vector_to_stream_0_2_0, '0', qtgui_time_sink_x_0, '0']
- [fir_filter_xxx_0, '0', blocks_stream_to_vector_0, '0']
- [fir_filter_xxx_0, '0', qtgui_freq_sink_x_0, '0']
- [fir_filter_xxx_0_0, '0', blocks_stream_to_vector_0_0, '0']
- [fir_filter_xxx_0_0_0, '0', blocks_stream_to_vector_0_0_0, '0']
- [fir_filter_xxx_0_0_1, '0', blocks_stream_to_vector_0_0_1, '0']
- [fir_filter_xxx_0_0_2, '0', blocks_stream_to_vector_0_0_2, '0']
- [krakensdr_doa_music_0, '0', blocks_vector_to_stream_0_2_0, '0']
- [krakensdr_krakensdr_source_0, '0', blocks_stream_to_vector_1, '0']
- [krakensdr_krakensdr_source_0, '0', fir_filter_xxx_0, '0']
- [krakensdr_krakensdr_source_0, '1', blocks_stream_to_vector_1_2, '0']
- [krakensdr_krakensdr_source_0, '1', fir_filter_xxx_0_0, '0']
- [krakensdr_krakensdr_source_0, '2', blocks_stream_to_vector_1_3, '0']
- [krakensdr_krakensdr_source_0, '2', fir_filter_xxx_0_0_0, '0']
- [krakensdr_krakensdr_source_0, '3', blocks_stream_to_vector_1_1, '0']
- [krakensdr_krakensdr_source_0, '3', fir_filter_xxx_0_0_1, '0']
- [krakensdr_krakensdr_source_0, '4', blocks_stream_to_vector_1_0, '0']
- [krakensdr_krakensdr_source_0, '4', fir_filter_xxx_0_0_2, '0']

metadata:
  file_format: 1
  grc_version: 3.10.3.0
